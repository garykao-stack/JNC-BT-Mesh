# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: BGM13P32F512GA SiliconLaboratories BGM13P32F512GA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BGM13P32F512GA; MESH_LIB_NATIVE; NVM3_DEFAULT_MAX_OBJECT_SIZE=512; ENABLE_LOGGING; NVM3_DEFAULT_NVM_SIZE=24576; HAL_CONFIG=1
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ..; ../protocol\bluetooth\bt_mesh\inc\common; ../protocol\bluetooth\bt_mesh\inc\soc; ../protocol\bluetooth\bt_mesh\inc; ../.; ../platform\common\inc; ../platform\service\sleeptimer\inc; ../platform\service\sleeptimer\src; ../platform\service\sleeptimer\config; ../platform\emlib\inc; ../platform\Device\SiliconLabs\BGM13\Include; ../hardware\module\config; ../platform\emdrv\sleep\inc; ../platform\emdrv\common\inc; ../platform\emdrv\uartdrv\inc; ../platform\emdrv\gpiointerrupt\inc; ../platform\CMSIS\Include; ../platform\emdrv\nvm3\inc; ../protocol\bluetooth\ble_stack\inc\soc; ../platform\radio\rail_lib\plugin\coexistence\hal\efr32; ../platform\radio\rail_lib\plugin\coexistence\common; ../platform\radio\rail_lib\plugin; ../platform\radio\rail_lib\common; ../platform\radio\rail_lib\chip\efr32\efr32xg1x; ../platform\radio\rail_lib\protocol\ble; ../platform\radio\rail_lib\protocol\ieee802154; ../platform\middleware\glib; ../platform\middleware\glib\dmd; ../platform\middleware\glib\dmd\ssd2119; ../platform\middleware\glib\glib; ../hardware\kit\common\drivers; ../hardware\kit\BGM13_BRD4306B\config; ../platform\bootloader\api; ../hardware\kit\common\bsp; ../platform\halconfig\inc\hal-config; ../hardware\kit\common\halconfig
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: soc-btmesh-sensor-server.bin
  ILINK.IlinkOutputFile: soc-btmesh-sensor-server.out
  ILINK.IlinkConfigDefines: __STACK_SIZE=0x1000
  ILINK.IlinkIcfFile: ../bgm13p32f512ga.icf
  ILINK.IlinkExtraOptions: --keep __iar_program_start; --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  group (top)
    ../protocol/bluetooth/bt_mesh/src/: mesh_lib.c mesh_serdeser.c mesh_sensor.c bg_application_properties.c
    ../: sensor.c temperature_sensor.c main.c people_count_sensor.c app.c buttons.c leds.c graphics.c dcd.c display_interface.c lcd_driver.c pti.c init_mcu.c init_board.c init_app.c gatt_db.c
    ../platform/service/sleeptimer/src/: sl_sleeptimer.c sl_sleeptimer_hal_prortc.c sl_sleeptimer_hal_rtcc.c sl_sleeptimer.c sl_sleeptimer_hal_prortc.c sl_sleeptimer_hal_rtcc.c
    ../platform/emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_system.c em_gpio.c em_i2c.c em_rmu.c em_rtcc.c em_usart.c em_eusart.c em_msc.c em_timer.c em_burtc.c em_cryotimer.c em_crypto.c em_se.c em_cmu.c em_emu.c
    ../platform/Device/SiliconLabs/BGM13/Source/IAR/: startup_bgm13.c
    ../platform/emdrv/sleep/src/: sleep.c sleep.c
    ../platform/emdrv/nvm3/src/: nvm3_default.c nvm3_hal_flash.c nvm3_lock.c
    ../protocol/bluetooth/ble_stack/src/soc/: coexistence-ble.c coexistence_counters-ble.c
    ../platform/radio/rail_lib/plugin/coexistence/hal/efr32/: coexistence-hal.c
    ../platform/radio/rail_lib/plugin/coexistence/common/: coexistence.c
    ../platform/Device/SiliconLabs/BGM13/Source/: system_bgm13.c
    ../platform/middleware/glib/glib/: bmp.c glib.c glib_bitmap.c glib_circle.c glib_font_narrow_6x8.c glib_font_normal_8x8.c glib_font_number_16x20.c glib_line.c glib_polygon.c glib_rectangle.c glib_string.c
    ../platform/middleware/glib/dmd/display/: dmd_display.c
    ../hardware/kit/common/drivers/: display.c displayls013b7dh03.c displaypalemlib.c mx25flash_spi.c udelay.c retargetserial.c retargetio.c i2cspm.c si7013.c tempsens.c
    ../platform/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../hardware/kit/common/bsp/: bsp_stk.c
  group gattdb
    ../: gatt.xml
  group lib
    ../protocol/bluetooth/lib/EFR32XG13X/IAR/: libbluetooth_mesh.a binapploader.o
    ../platform/emdrv/nvm3/lib/: libnvm3_CM4_iar.a
    ../platform/radio/rail_lib/autogen/librail_release/: librail_config_bgm13p32f512ga_iar.a librail_module_efr32xg13_iar_release.a
